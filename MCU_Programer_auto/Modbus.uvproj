# Keil uVision project Modbus.uvproj, settings and files
target ROM_AUTOMATIC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Modbusrtu
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC100Series\Include;..\Library\NUC1xx-LB_002\Include;..\Library\NuMakerLib\Include;..\Library\StdDriver\inc;..\MCU_Programer_auto
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group USER
    ./: main.c control.c control.h PC.c PC.h History.txt
    ../Library/NuMakerLib/Source/: SYS_init.c
  group LIB
    ../Library/StdDriver/src/: clk.c gpio.c sys.c timer.c uart.c
  group H
    ./: General.c General.h
  group Init
    ./: Init.c Init.h
  group Interrupt
    ./: Interrupt.c Interrupt.h
  group Modbus
    ./: PetitModbus.c PetitModbus.h PetitModbusPort.c PetitModbusPort.h PetitRegConstant.c
